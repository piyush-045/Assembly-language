# Keil uVision project ADC_First.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ADC_First +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc_first.asm
