# Keil uVision project pwm_complementry.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: pwm_complementry
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pwm_complementry.asm
