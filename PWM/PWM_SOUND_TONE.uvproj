# Keil uVision project PWM_SOUND_TONE.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: PWM_SOUND_TONE
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: PWM_SOUND_TONE.asm
